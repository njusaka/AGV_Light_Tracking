# Keil uVision project Car.uvprojx, settings and files
target Car (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TIMER +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;.\__Header__;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\_Header_;..\HARDWARE\MPU6050\eMPL;..\HARDWARE\PID;..\HARDWARE\_Header_;..\HARDWARE\BALANCE\DataScope_DP;..\HARDWARE\BALANCE\show;..\STM32F10x_FWLib\inc;..\Modules\include;..\Algorithm_Lib\include;..\Modules\include;..\Algorithm_Lib\include;..\HARDWARE\SERVO
  asm include: .\__Header__
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c system_stm32f10x.c stm32f10x_it.c
    ../HARDWARE/MPU6050/eMPL/: inv_mpu.c
    ./__Header__/: car.h config.h
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/MPU6050/: mpu6050.c mpuiic.c
    ../HARDWARE/MPU6050/eMPL/: inv_mpu_dmp_motion_driver.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/BALANCE/DataScope_DP/: DataScope_DP.C
    ../HARDWARE/SERVO/: servo.c
  group SYSTEM
    ../HARDWARE/ENCODER/: encoder.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_exti.c
  group Modules
    ../Modules/: odom.c agv_control.c find.c data.c
    ../Modules/include/: agv_param.h
  group Algorithm_Lib
    ../Algorithm_Lib/: PID.c
  group README
    ../: README.TXT
